# IAR project easyRTOS.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: UnspecifiedSTM8 STM8 - Unspecified
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: stm8s-periphs; kernel; 
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group kernel
    kernel/: easyRTOS.h easyRTOSkernel.c easyRTOSkernel.h easyRTOSport.c easyRTOSport.h easyRTOSportAsm.s easyRTOSQueue.c easyRTOSQueue.h easyRTOSSem.c easyRTOSSem.h easyRTOSTimer.c easyRTOSTimer.h
  group stm8s
    stm8s-periphs/: stm8s.h stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
    ./: stm8s_conf.h
  group test
    ./: mutexTestmain.c queueTestmain.c
